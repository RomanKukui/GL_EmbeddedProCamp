# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Application;.\STM32F30x_DSP_StdPeriph_Lib_V1.2.3\Libraries\CMSIS\Include;.\STM32F30x_DSP_StdPeriph_Lib_V1.2.3\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\STM32F30x_DSP_StdPeriph_Lib_V1.2.3\Libraries\STM32F30x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source
    ./Application/: main.c
  group Drivers
    ./Application/: stm32f30x_it.c
    ./STM32F30x_DSP_StdPeriph_Lib_V1.2.3/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_tim.c
  group Startup
    ./Application/: system_stm32f30x.c
    ./STM32F30x_DSP_StdPeriph_Lib_V1.2.3/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
